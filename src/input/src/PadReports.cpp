#include "gs/input/PadReports.h"

#include <algorithm>
#include <array>

namespace gs::input {

namespace {

constexpr std::uint8_t kInputReport = 0x01;
constexpr std::size_t kXboxInputSize = 17;
constexpr std::size_t kSonyInputSize = 64;
constexpr std::size_t kGenericInputSize = 14;
constexpr std::uint8_t kXboxRumbleReport = 0x03;
constexpr std::uint8_t kDualShock4RumbleReport = 0x05;
constexpr std::uint8_t kDualSenseRumbleReport = 0x02;
constexpr int kXboxMagnitudeMax = 100;
constexpr std::uint8_t kDualShock4Status = 0x1B;
constexpr std::uint8_t kDualSenseStatus = 0x2A;
constexpr std::uint8_t kTouchInactive = 0x80;

constexpr auto kXboxDescriptor = std::to_array<std::uint8_t>({
    0x05, 0x01, 0x09, 0x05, 0xA1, 0x01, 0x85, 0x01, 0x09, 0x01, 0xA1, 0x00, 0x09, 0x30, 0x09, 0x31, 0x15, 0x00,
    0x27, 0xFF, 0xFF, 0x00, 0x00, 0x95, 0x02, 0x75, 0x10, 0x81, 0x02, 0xC0, 0x09, 0x01, 0xA1, 0x00, 0x09, 0x32,
    0x09, 0x35, 0x15, 0x00, 0x27, 0xFF, 0xFF, 0x00, 0x00, 0x95, 0x02, 0x75, 0x10, 0x81, 0x02, 0xC0, 0x05, 0x02,
    0x09, 0xC5, 0x15, 0x00, 0x26, 0xFF, 0x03, 0x95, 0x01, 0x75, 0x0A, 0x81, 0x02, 0x15, 0x00, 0x25, 0x00, 0x75,
    0x06, 0x95, 0x01, 0x81, 0x03, 0x05, 0x02, 0x09, 0xC4, 0x15, 0x00, 0x26, 0xFF, 0x03, 0x95, 0x01, 0x75, 0x0A,
    0x81, 0x02, 0x15, 0x00, 0x25, 0x00, 0x75, 0x06, 0x95, 0x01, 0x81, 0x03, 0x05, 0x01, 0x09, 0x39, 0x15, 0x01,
    0x25, 0x08, 0x35, 0x00, 0x46, 0x3B, 0x01, 0x66, 0x14, 0x00, 0x75, 0x04, 0x95, 0x01, 0x81, 0x42, 0x75, 0x04,
    0x95, 0x01, 0x15, 0x00, 0x25, 0x00, 0x35, 0x00, 0x45, 0x00, 0x65, 0x00, 0x81, 0x03, 0x05, 0x09, 0x19, 0x01,
    0x29, 0x0F, 0x15, 0x00, 0x25, 0x01, 0x75, 0x01, 0x95, 0x0F, 0x81, 0x02, 0x15, 0x00, 0x25, 0x00, 0x75, 0x01,
    0x95, 0x01, 0x81, 0x03, 0x05, 0x0C, 0x0A, 0xB2, 0x00, 0x15, 0x00, 0x25, 0x01, 0x95, 0x01, 0x75, 0x01, 0x81,
    0x02, 0x15, 0x00, 0x25, 0x00, 0x75, 0x07, 0x95, 0x01, 0x81, 0x03, 0x05, 0x0F, 0x09, 0x21, 0x85, 0x03, 0xA1,
    0x02, 0x09, 0x97, 0x15, 0x00, 0x25, 0x01, 0x75, 0x04, 0x95, 0x01, 0x91, 0x02, 0x15, 0x00, 0x25, 0x00, 0x75,
    0x04, 0x95, 0x01, 0x91, 0x03, 0x09, 0x70, 0x15, 0x00, 0x25, 0x64, 0x75, 0x08, 0x95, 0x04, 0x91, 0x02, 0x09,
    0x50, 0x66, 0x01, 0x10, 0x55, 0x0E, 0x15, 0x00, 0x26, 0xFF, 0x00, 0x75, 0x08, 0x95, 0x01, 0x91, 0x02, 0x09,
    0xA7, 0x15, 0x00, 0x26, 0xFF, 0x00, 0x75, 0x08, 0x95, 0x01, 0x91, 0x02, 0x65, 0x00, 0x55, 0x00, 0x09, 0x7C,
    0x15, 0x00, 0x26, 0xFF, 0x00, 0x75, 0x08, 0x95, 0x01, 0x91, 0x02, 0xC0, 0xC0,
});

constexpr auto kDualShock4Descriptor = std::to_array<std::uint8_t>({
    0x05, 0x01, 0x09, 0x05, 0xA1, 0x01, 0x85, 0x01, 0x09, 0x30, 0x09, 0x31, 0x09, 0x32, 0x09, 0x35, 0x15, 0x00,
    0x26, 0xFF, 0x00, 0x75, 0x08, 0x95, 0x04, 0x81, 0x02, 0x09, 0x39, 0x15, 0x00, 0x25, 0x07, 0x35, 0x00, 0x46,
    0x3B, 0x01, 0x65, 0x14, 0x75, 0x04, 0x95, 0x01, 0x81, 0x42, 0x65, 0x00, 0x05, 0x09, 0x19, 0x01, 0x29, 0x0E,
    0x15, 0x00, 0x25, 0x01, 0x75, 0x01, 0x95, 0x0E, 0x81, 0x02, 0x06, 0x00, 0xFF, 0x09, 0x20, 0x75, 0x06, 0x95,
    0x01, 0x15, 0x00, 0x25, 0x7F, 0x81, 0x02, 0x05, 0x01, 0x09, 0x33, 0x09, 0x34, 0x15, 0x00, 0x26, 0xFF, 0x00,
    0x75, 0x08, 0x95, 0x02, 0x81, 0x02, 0x06, 0x00, 0xFF, 0x09, 0x21, 0x95, 0x36, 0x81, 0x02, 0x85, 0x05, 0x09,
    0x22, 0x95, 0x1F, 0x91, 0x02, 0x85, 0x04, 0x09, 0x23, 0x95, 0x24, 0xB1, 0x02, 0x85, 0x02, 0x09, 0x24, 0x95,
    0x24, 0xB1, 0x02, 0x85, 0x08, 0x09, 0x25, 0x95, 0x03, 0xB1, 0x02, 0x85, 0x10, 0x09, 0x26, 0x95, 0x04, 0xB1,
    0x02, 0x85, 0x11, 0x09, 0x27, 0x95, 0x02, 0xB1, 0x02, 0x85, 0x12, 0x06, 0x02, 0xFF, 0x09, 0x21, 0x95, 0x0F,
    0xB1, 0x02, 0x85, 0x13, 0x09, 0x22, 0x95, 0x16, 0xB1, 0x02, 0x85, 0x14, 0x06, 0x05, 0xFF, 0x09, 0x20, 0x95,
    0x10, 0xB1, 0x02, 0x85, 0x15, 0x09, 0x21, 0x95, 0x2C, 0xB1, 0x02, 0x06, 0x80, 0xFF, 0x85, 0x80, 0x09, 0x20,
    0x95, 0x06, 0xB1, 0x02, 0x85, 0x81, 0x09, 0x21, 0x95, 0x06, 0xB1, 0x02, 0x85, 0x82, 0x09, 0x22, 0x95, 0x05,
    0xB1, 0x02, 0x85, 0x83, 0x09, 0x23, 0x95, 0x01, 0xB1, 0x02, 0x85, 0x84, 0x09, 0x24, 0x95, 0x04, 0xB1, 0x02,
    0x85, 0x85, 0x09, 0x25, 0x95, 0x06, 0xB1, 0x02, 0x85, 0x86, 0x09, 0x26, 0x95, 0x06, 0xB1, 0x02, 0x85, 0x87,
    0x09, 0x27, 0x95, 0x23, 0xB1, 0x02, 0x85, 0x88, 0x09, 0x28, 0x95, 0x22, 0xB1, 0x02, 0x85, 0x89, 0x09, 0x29,
    0x95, 0x02, 0xB1, 0x02, 0x85, 0x90, 0x09, 0x30, 0x95, 0x05, 0xB1, 0x02, 0x85, 0x91, 0x09, 0x31, 0x95, 0x03,
    0xB1, 0x02, 0x85, 0x92, 0x09, 0x32, 0x95, 0x03, 0xB1, 0x02, 0x85, 0x93, 0x09, 0x33, 0x95, 0x0C, 0xB1, 0x02,
    0x85, 0xA0, 0x09, 0x40, 0x95, 0x06, 0xB1, 0x02, 0x85, 0xA1, 0x09, 0x41, 0x95, 0x01, 0xB1, 0x02, 0x85, 0xA2,
    0x09, 0x42, 0x95, 0x01, 0xB1, 0x02, 0x85, 0xA3, 0x09, 0x43, 0x95, 0x30, 0xB1, 0x02, 0x85, 0xA4, 0x09, 0x44,
    0x95, 0x0D, 0xB1, 0x02, 0x85, 0xA5, 0x09, 0x45, 0x95, 0x15, 0xB1, 0x02, 0x85, 0xA6, 0x09, 0x46, 0x95, 0x15,
    0xB1, 0x02, 0x85, 0xF0, 0x09, 0x47, 0x95, 0x3F, 0xB1, 0x02, 0x85, 0xF1, 0x09, 0x48, 0x95, 0x3F, 0xB1, 0x02,
    0x85, 0xF2, 0x09, 0x49, 0x95, 0x0F, 0xB1, 0x02, 0x85, 0xA7, 0x09, 0x4A, 0x95, 0x01, 0xB1, 0x02, 0x85, 0xA8,
    0x09, 0x4B, 0x95, 0x01, 0xB1, 0x02, 0x85, 0xA9, 0x09, 0x4C, 0x95, 0x08, 0xB1, 0x02, 0x85, 0xAA, 0x09, 0x4E,
    0x95, 0x01, 0xB1, 0x02, 0x85, 0xAB, 0x09, 0x4F, 0x95, 0x39, 0xB1, 0x02, 0x85, 0xAC, 0x09, 0x50, 0x95, 0x39,
    0xB1, 0x02, 0x85, 0xAD, 0x09, 0x51, 0x95, 0x0B, 0xB1, 0x02, 0x85, 0xAE, 0x09, 0x52, 0x95, 0x01, 0xB1, 0x02,
    0x85, 0xAF, 0x09, 0x53, 0x95, 0x02, 0xB1, 0x02, 0x85, 0xB0, 0x09, 0x54, 0x95, 0x3F, 0xB1, 0x02, 0xC0,
});

constexpr auto kDualSenseDescriptor = std::to_array<std::uint8_t>({
    0x05, 0x01, 0x09, 0x05, 0xA1, 0x01, 0x85, 0x01, 0x09, 0x30, 0x09, 0x31, 0x09, 0x32, 0x09, 0x35, 0x09, 0x33,
    0x09, 0x34, 0x15, 0x00, 0x26, 0xFF, 0x00, 0x75, 0x08, 0x95, 0x06, 0x81, 0x02, 0x06, 0x00, 0xFF, 0x09, 0x20,
    0x95, 0x01, 0x81, 0x02, 0x05, 0x01, 0x09, 0x39, 0x15, 0x00, 0x25, 0x07, 0x35, 0x00, 0x46, 0x3B, 0x01, 0x65,
    0x14, 0x75, 0x04, 0x95, 0x01, 0x81, 0x42, 0x65, 0x00, 0x05, 0x09, 0x19, 0x01, 0x29, 0x0F, 0x15, 0x00, 0x25,
    0x01, 0x75, 0x01, 0x95, 0x0F, 0x81, 0x02, 0x06, 0x00, 0xFF, 0x09, 0x21, 0x95, 0x0D, 0x81, 0x02, 0x06, 0x00,
    0xFF, 0x09, 0x22, 0x15, 0x00, 0x26, 0xFF, 0x00, 0x75, 0x08, 0x95, 0x34, 0x81, 0x02, 0x85, 0x02, 0x09, 0x23,
    0x95, 0x2F, 0x91, 0x02, 0x85, 0x05, 0x09, 0x33, 0x95, 0x28, 0xB1, 0x02, 0x85, 0x08, 0x09, 0x34, 0x95, 0x2F,
    0xB1, 0x02, 0x85, 0x09, 0x09, 0x24, 0x95, 0x13, 0xB1, 0x02, 0x85, 0x0A, 0x09, 0x25, 0x95, 0x1A, 0xB1, 0x02,
    0x85, 0x20, 0x09, 0x26, 0x95, 0x3F, 0xB1, 0x02, 0x85, 0x21, 0x09, 0x27, 0x95, 0x04, 0xB1, 0x02, 0x85, 0x22,
    0x09, 0x40, 0x95, 0x3F, 0xB1, 0x02, 0x85, 0x80, 0x09, 0x28, 0x95, 0x3F, 0xB1, 0x02, 0x85, 0x81, 0x09, 0x29,
    0x95, 0x3F, 0xB1, 0x02, 0x85, 0x82, 0x09, 0x2A, 0x95, 0x09, 0xB1, 0x02, 0x85, 0x83, 0x09, 0x2B, 0x95, 0x3F,
    0xB1, 0x02, 0x85, 0x84, 0x09, 0x2C, 0x95, 0x3F, 0xB1, 0x02, 0x85, 0x85, 0x09, 0x2D, 0x95, 0x02, 0xB1, 0x02,
    0x85, 0xA0, 0x09, 0x2E, 0x95, 0x01, 0xB1, 0x02, 0x85, 0xE0, 0x09, 0x2F, 0x95, 0x3F, 0xB1, 0x02, 0x85, 0xF0,
    0x09, 0x30, 0x95, 0x3F, 0xB1, 0x02, 0x85, 0xF1, 0x09, 0x31, 0x95, 0x3F, 0xB1, 0x02, 0x85, 0xF2, 0x09, 0x32,
    0x95, 0x0F, 0xB1, 0x02, 0x85, 0xF4, 0x09, 0x35, 0x95, 0x3F, 0xB1, 0x02, 0x85, 0xF5, 0x09, 0x36, 0x95, 0x03,
    0xB1, 0x02, 0xC0,
});

constexpr auto kGenericDescriptor = std::to_array<std::uint8_t>({
    0x05, 0x01, 0x09, 0x05, 0xA1, 0x01, 0x85, 0x01, 0x05, 0x09, 0x19, 0x01, 0x29, 0x10, 0x15, 0x00, 0x25, 0x01,
    0x75, 0x01, 0x95, 0x10, 0x81, 0x02, 0x05, 0x01, 0x09, 0x39, 0x15, 0x01, 0x25, 0x08, 0x35, 0x00, 0x46, 0x3B,
    0x01, 0x66, 0x14, 0x00, 0x75, 0x04, 0x95, 0x01, 0x81, 0x42, 0x75, 0x04, 0x95, 0x01, 0x81, 0x03, 0x65, 0x00,
    0x45, 0x00, 0x09, 0x30, 0x09, 0x31, 0x09, 0x32, 0x09, 0x35, 0x16, 0x00, 0x80, 0x26, 0xFF, 0x7F, 0x75, 0x10,
    0x95, 0x04, 0x81, 0x02, 0x05, 0x02, 0x09, 0xC5, 0x09, 0xC4, 0x15, 0x00, 0x26, 0xFF, 0x00, 0x75, 0x08, 0x95,
    0x02, 0x81, 0x02, 0xC0,
});

constexpr auto kDualShock4Calibration = std::to_array<std::uint8_t>({
    0x02, 0xFE, 0xFF, 0xFC, 0xFF, 0xFD, 0xFF, 0xA2, 0x22, 0x5B, 0xDD, 0xD0, 0x22, 0x2D, 0xDD, 0xC4, 0x22, 0x3A, 0xDD,
    0x1C, 0x02, 0x1C, 0x02, 0xA0, 0x1F, 0x5D, 0xE0, 0xD6, 0x20, 0x2C, 0xDF, 0xF3, 0x1E, 0x0F, 0xE1, 0x06, 0x00,
});

constexpr auto kDualShock4Address = std::to_array<std::uint8_t>({0x81, 0x01, 0x00, 0x5A, 0x53, 0x47, 0x02});

constexpr auto kDualShock4Pairing = std::to_array<std::uint8_t>({
    0x12, 0x01, 0x00, 0x5A, 0x53, 0x47, 0x02, 0x08, 0x25, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
});

constexpr auto kDualShock4Firmware = std::to_array<std::uint8_t>({
    0xA3, 'S',  'e',  'p',  ' ',  '2',  '1',  ' ',  '2',  '0',  '1',  '8',  0x00, 0x00, 0x00, 0x00, 0x00,
    '0',  '4',  ':',  '5',  '0',  ':',  '5',  '1',  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
    0x00, 0x00, 0xB4, 0x01, 0x00, 0x00, 0x00, 0x0A, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
});

constexpr auto kDualSenseCalibration = std::to_array<std::uint8_t>({
    0x05, 0xFF, 0xFF, 0x02, 0x00, 0x00, 0x00, 0x5D, 0x22, 0xA4, 0xDD, 0x6A, 0x22, 0x96, 0xDD, 0x5E, 0x22,
    0xA2, 0xDD, 0x1C, 0x02, 0x1C, 0x02, 0x09, 0x20, 0xF6, 0xDF, 0x22, 0x20, 0xDE, 0xDF, 0x0A, 0x20, 0xF4,
    0xDF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
});

constexpr auto kDualSensePairing = std::to_array<std::uint8_t>({
    0x09, 0x01, 0x00, 0x5A, 0x53, 0x47, 0x02, 0x08, 0x25, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00,
});

constexpr auto kDualSenseFirmware = std::to_array<std::uint8_t>({
    0x20, 'J',  'u',  'n',  ' ',  '1',  '9',  ' ',  '2',  '0',  '2',  '3',  '1',  '4',  ':',  '4',  '7',  ':',
    '3',  '4',  0x03, 0x00, 0x44, 0x00, 0x13, 0x06, 0x00, 0x00, 0x2A, 0x00, 0x01, 0x01, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x24, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
});

constexpr std::array<PadFeature, 4> kDualShock4Features{{
    {0x02, kDualShock4Calibration},
    {0x81, kDualShock4Address},
    {0xA3, kDualShock4Firmware},
    {0x12, kDualShock4Pairing},
}};

constexpr std::array<PadFeature, 3> kDualSenseFeatures{{
    {0x09, kDualSensePairing},
    {0x20, kDualSenseFirmware},
    {0x05, kDualSenseCalibration},
}};

constexpr PadModel kGeneric{.family = PadFamily::Generic,
                            .vendorId = 0x1209,
                            .productId = 0x0002,
                            .bus = kPadBusUsb,
                            .name = "GameScrcpy Gamepad",
                            .descriptor = kGenericDescriptor,
                            .features = {},
                            .inputReport = kInputReport,
                            .inputSize = kGenericInputSize,
                            .rumble = false};

constexpr PadModel kXbox{.family = PadFamily::Xbox,
                         .vendorId = 0x045E,
                         .productId = 0x0B13,
                         .bus = kPadBusBluetooth,
                         .name = "Xbox Wireless Controller",
                         .descriptor = kXboxDescriptor,
                         .features = {},
                         .inputReport = kInputReport,
                         .inputSize = kXboxInputSize,
                         .rumble = true};

constexpr PadModel kDualShock4{.family = PadFamily::DualShock4,
                               .vendorId = 0x054C,
                               .productId = 0x09CC,
                               .bus = kPadBusUsb,
                               .name = "Sony Interactive Entertainment Wireless Controller",
                               .descriptor = kDualShock4Descriptor,
                               .features = kDualShock4Features,
                               .inputReport = kInputReport,
                               .inputSize = kSonyInputSize,
                               .rumble = true};

constexpr PadModel kDualSense{.family = PadFamily::DualSense,
                              .vendorId = 0x054C,
                              .productId = 0x0CE6,
                              .bus = kPadBusUsb,
                              .name = "Sony Interactive Entertainment DualSense Wireless Controller",
                              .descriptor = kDualSenseDescriptor,
                              .features = kDualSenseFeatures,
                              .inputReport = kInputReport,
                              .inputSize = kSonyInputSize,
                              .rumble = true};

struct ButtonBit {
    std::uint32_t button = 0;
    std::size_t at = 0;
    std::uint8_t bit = 0;
};

constexpr std::array<ButtonBit, 12> kXboxButtons{{
    {pad_button::kSouth, 14, 0x01},
    {pad_button::kEast, 14, 0x02},
    {pad_button::kWest, 14, 0x08},
    {pad_button::kNorth, 14, 0x10},
    {pad_button::kLeftShoulder, 14, 0x40},
    {pad_button::kRightShoulder, 14, 0x80},
    {pad_button::kBack, 15, 0x04},
    {pad_button::kStart, 15, 0x08},
    {pad_button::kGuide, 15, 0x10},
    {pad_button::kLeftStick, 15, 0x20},
    {pad_button::kRightStick, 15, 0x40},
    {pad_button::kMisc, 16, 0x01},
}};

constexpr std::array<ButtonBit, 14> kDualShock4Buttons{{
    {pad_button::kWest, 5, 0x10},
    {pad_button::kSouth, 5, 0x20},
    {pad_button::kEast, 5, 0x40},
    {pad_button::kNorth, 5, 0x80},
    {pad_button::kLeftShoulder, 6, 0x01},
    {pad_button::kRightShoulder, 6, 0x02},
    {pad_button::kLeftTrigger, 6, 0x04},
    {pad_button::kRightTrigger, 6, 0x08},
    {pad_button::kBack, 6, 0x10},
    {pad_button::kStart, 6, 0x20},
    {pad_button::kLeftStick, 6, 0x40},
    {pad_button::kRightStick, 6, 0x80},
    {pad_button::kGuide, 7, 0x01},
    {pad_button::kTouchpad, 7, 0x02},
}};

constexpr std::array<ButtonBit, 15> kDualSenseButtons{{
    {pad_button::kWest, 8, 0x10},
    {pad_button::kSouth, 8, 0x20},
    {pad_button::kEast, 8, 0x40},
    {pad_button::kNorth, 8, 0x80},
    {pad_button::kLeftShoulder, 9, 0x01},
    {pad_button::kRightShoulder, 9, 0x02},
    {pad_button::kLeftTrigger, 9, 0x04},
    {pad_button::kRightTrigger, 9, 0x08},
    {pad_button::kBack, 9, 0x10},
    {pad_button::kStart, 9, 0x20},
    {pad_button::kLeftStick, 9, 0x40},
    {pad_button::kRightStick, 9, 0x80},
    {pad_button::kGuide, 10, 0x01},
    {pad_button::kTouchpad, 10, 0x02},
    {pad_button::kMisc, 10, 0x04},
}};

constexpr std::array<std::size_t, 6> kDualShock4Contacts{35, 39, 44, 48, 53, 57};
constexpr std::array<std::size_t, 2> kDualSenseContacts{33, 37};

template <std::size_t N>
void setButtons(std::vector<std::uint8_t>& report, std::uint32_t buttons, const std::array<ButtonBit, N>& table) noexcept
{
    for (const ButtonBit& entry : table) {
        if ((buttons & entry.button) != 0) {
            report[entry.at] = static_cast<std::uint8_t>(report[entry.at] | entry.bit);
        }
    }
}

void put16(std::vector<std::uint8_t>& report, std::size_t at, std::uint16_t value) noexcept
{
    report[at] = static_cast<std::uint8_t>(value & 0xFFU);
    report[at + 1] = static_cast<std::uint8_t>(value >> 8U);
}

std::uint8_t stick8(std::int16_t value) noexcept
{
    return static_cast<std::uint8_t>((static_cast<int>(value) + 32768) >> 8);
}

std::uint16_t stick16(std::int16_t value) noexcept
{
    return static_cast<std::uint16_t>(static_cast<int>(value) + 32768);
}

std::uint16_t trigger10(std::uint8_t value) noexcept
{
    return static_cast<std::uint16_t>(value * 1023 / 255);
}

std::uint8_t hatFromOne(std::uint8_t hat) noexcept
{
    return hat < kPadHatCentred ? static_cast<std::uint8_t>(hat + 1) : std::uint8_t{0};
}

std::uint8_t hatFromZero(std::uint8_t hat) noexcept
{
    return std::min(hat, kPadHatCentred);
}

std::vector<std::uint8_t> xboxReport(const PadPassState& state)
{
    std::vector<std::uint8_t> report(kXboxInputSize, 0);
    report[0] = kInputReport;
    put16(report, 1, stick16(state.leftX));
    put16(report, 3, stick16(state.leftY));
    put16(report, 5, stick16(state.rightX));
    put16(report, 7, stick16(state.rightY));
    put16(report, 9, trigger10(state.leftTrigger));
    put16(report, 11, trigger10(state.rightTrigger));
    report[13] = hatFromOne(state.hat);
    setButtons(report, state.buttons, kXboxButtons);
    return report;
}

std::vector<std::uint8_t> dualShock4Report(const PadPassState& state)
{
    std::vector<std::uint8_t> report(kSonyInputSize, 0);
    report[0] = kInputReport;
    report[1] = stick8(state.leftX);
    report[2] = stick8(state.leftY);
    report[3] = stick8(state.rightX);
    report[4] = stick8(state.rightY);
    report[5] = hatFromZero(state.hat);
    setButtons(report, state.buttons, kDualShock4Buttons);
    report[8] = state.leftTrigger;
    report[9] = state.rightTrigger;
    report[30] = kDualShock4Status;
    report[33] = 1;
    for (const std::size_t contact : kDualShock4Contacts) {
        report[contact] = kTouchInactive;
    }
    return report;
}

std::vector<std::uint8_t> dualSenseReport(const PadPassState& state)
{
    std::vector<std::uint8_t> report(kSonyInputSize, 0);
    report[0] = kInputReport;
    report[1] = stick8(state.leftX);
    report[2] = stick8(state.leftY);
    report[3] = stick8(state.rightX);
    report[4] = stick8(state.rightY);
    report[5] = state.leftTrigger;
    report[6] = state.rightTrigger;
    report[8] = hatFromZero(state.hat);
    setButtons(report, state.buttons, kDualSenseButtons);
    for (const std::size_t contact : kDualSenseContacts) {
        report[contact] = kTouchInactive;
    }
    report[53] = kDualSenseStatus;
    return report;
}

std::vector<std::uint8_t> genericReport(const PadPassState& state)
{
    std::vector<std::uint8_t> report(kGenericInputSize, 0);
    report[0] = kInputReport;
    put16(report, 1, static_cast<std::uint16_t>(state.buttons & 0xFFFFU));
    report[3] = hatFromOne(state.hat);
    put16(report, 4, static_cast<std::uint16_t>(state.leftX));
    put16(report, 6, static_cast<std::uint16_t>(state.leftY));
    put16(report, 8, static_cast<std::uint16_t>(state.rightX));
    put16(report, 10, static_cast<std::uint16_t>(state.rightY));
    report[12] = state.leftTrigger;
    report[13] = state.rightTrigger;
    return report;
}

std::uint16_t byteMotor(std::uint8_t value) noexcept
{
    return static_cast<std::uint16_t>(value * 257);
}

std::uint16_t percentMotor(std::uint8_t enable, std::uint8_t bit, std::uint8_t value) noexcept
{
    if ((enable & bit) == 0) {
        return 0;
    }
    return static_cast<std::uint16_t>(std::min<int>(value, kXboxMagnitudeMax) * 65535 / kXboxMagnitudeMax);
}

}

const PadModel& padModel(PadFamily family) noexcept
{
    switch (family) {
    case PadFamily::Xbox:
        return kXbox;
    case PadFamily::DualShock4:
        return kDualShock4;
    case PadFamily::DualSense:
        return kDualSense;
    case PadFamily::Generic:
        break;
    }
    return kGeneric;
}

std::vector<std::uint8_t> padInputReport(PadFamily family, const PadPassState& state)
{
    switch (family) {
    case PadFamily::Xbox:
        return xboxReport(state);
    case PadFamily::DualShock4:
        return dualShock4Report(state);
    case PadFamily::DualSense:
        return dualSenseReport(state);
    case PadFamily::Generic:
        break;
    }
    return genericReport(state);
}

std::optional<PadRumble> padRumble(PadFamily family, std::span<const std::uint8_t> output) noexcept
{
    switch (family) {
    case PadFamily::Xbox: {
        if (output.size() < 6 || output[0] != kXboxRumbleReport) {
            return std::nullopt;
        }
        const std::uint8_t enable = output[1];
        return PadRumble{.strong = percentMotor(enable, 0x02, output[4]),
                         .weak = percentMotor(enable, 0x01, output[5]),
                         .leftTrigger = percentMotor(enable, 0x08, output[2]),
                         .rightTrigger = percentMotor(enable, 0x04, output[3])};
    }
    case PadFamily::DualShock4:
        if (output.size() < 6 || output[0] != kDualShock4RumbleReport || (output[1] & 0x01U) == 0) {
            return std::nullopt;
        }
        return PadRumble{.strong = byteMotor(output[5]), .weak = byteMotor(output[4])};
    case PadFamily::DualSense: {
        if (output.size() < 5 || output[0] != kDualSenseRumbleReport) {
            return std::nullopt;
        }
        const bool classic = (output[1] & 0x01U) != 0;
        const bool improved = output.size() > 39 && (output[39] & 0x04U) != 0;
        if (!classic && !improved) {
            return std::nullopt;
        }
        return PadRumble{.strong = byteMotor(output[4]), .weak = byteMotor(output[3])};
    }
    case PadFamily::Generic:
        break;
    }
    return std::nullopt;
}

}
